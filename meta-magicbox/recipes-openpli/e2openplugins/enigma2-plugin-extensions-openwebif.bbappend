inherit magicbox-plugin-languages
PR_append = ".magicbox1"
