# Keep target locale generation independent of the upstream distro defaults.
GLIBC_GENERATE_LOCALES = "en_GB.UTF-8 tr_TR.UTF-8"
LOCALE_UTF8_ONLY = "1"
LOCALE_UTF8_IS_DEFAULT = "1"
PR_append = ".magicbox1"
